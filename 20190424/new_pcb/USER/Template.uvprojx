# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_USB_FS
  c include: ..\CORE;..\USER;..\SYSTEM;..\HALLIB\Inc;..\BSP;..\FATFS\src;..\APP;..\MALLOC;..\USB\STM32_USB_Host_Library\Class\MSC\Inc;..\USB\STM32_USB_Host_Library\Core\Inc;..\USB\USB_APP;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\JMP;..\MOTION
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c FreeRTOSConfig.h
  group SYSTEM
    ../SYSTEM/: tmdelay.c tmsys.c
  group CORE
    ../CORE/: startup_stm32h743xx.s
  group HALLIB
    ../HALLIB/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group BSP
    ../BSP/: bsp_gpio.c bsp_timer.c bsp_uart.c bsp_sdram.c bsp_test.c bsp_qspi.c w25qxx.c bsp_iwdg.c bsp_exti.c bsp_nand.c bsp_ftl.c bsp_mpu.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group APP
    ../APP/: app_qspi_flash_fatfs.c app_nand_flash_fatfs.c app_beep.c
  group MALLOC
    ../MALLOC/: tmmalloc.c
  group USB_HOST
    ../USB/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group USB_CORE
    ../USB/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group USB_APP
    ../USB/USB_APP/: usbh_conf.c usbh_diskio.c usb_test.c usb_app.c
  group FreeRTOS/Src
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group FreeRTOS/Ports
    ../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group JMP
    ../JMP/: jmp_config.h jmp_command_execution.c jmp_gcode_analysis.c jmp_gui.c jmp_param_state.c jmp_storage_read.c jmp_ex_config.c jmp_print_time.c jmp_script.c jmp_breakpoint.c
  group MOTION
    ../MOTION/: jmp_motion.c planner.c stepper.c block_manage.c
