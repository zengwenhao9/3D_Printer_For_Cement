# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F446ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,__RTX
  c misc: --diag_suppress 3731
  c include: ..\USER;..\CORE;..\HALLIB\Inc;..\SYSTEM;..\BSP;..\RL-ARM\Config;..\RL-ARM\Driver;..\RL-ARM\RL-RTX\inc;..\RL-ARM\RL-RTX\portable;..\RL-ARM\RL-USB;..\RL-ARM\RL-USB\INC;..\FATFS\exfuns;..\FATFS\src;..\APP;..\JMP;..\MOTION
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
    ../RL-ARM/Config/: RTX_Conf_CM.c usb_config.c
  group CORE
    ../CORE/: startup_stm32f446xx.s
  group HALLIB
    ../HALLIB/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group SYSTEM
    ../SYSTEM/: tmdelay.c tmsys.c
  group BSP
    ../BSP/: bsp_gpio.c bsp_spi.c bsp_uart.c w25qxx.c bsp_timer.c
  group RTX/Src
    ../RL-ARM/RL-RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RTX/Port
    ../RL-ARM/RL-RTX/portable/: HAL_CM4.c SVC_Table.s
  group RL-USB/Lib
    ../RL-ARM/RL-USB/: USB_CM3.lib
  group RL-USB/Driver
    ../RL-ARM/RL-USB/: usbh_stm32f40x.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: cc936.c
  group APP
    ../APP/: app_usb.c
  group JMP
    ../JMP/: jmp_config.h jmp_command_execution.c jmp_gcode_analysis.c jmp_storage_read.c jmp_param_state.c jmp_gui.c
  group MOTION
    ../MOTION/: jmp_motion.c planner.c stepper.c
